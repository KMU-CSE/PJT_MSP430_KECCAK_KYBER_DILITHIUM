<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\dilithium3_ref.ewp</path>
    </project>
    <batchBuild />
</workspace>
