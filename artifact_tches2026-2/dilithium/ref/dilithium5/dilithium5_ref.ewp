# IAR project dilithium5_ref.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlmff.h
  General.OGChipSelectMenu: MSP430F67791 MSP430F67791
  General.GStackSize2: 30000
  General.GHeapSize2: 1000
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 2
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f67791.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430fn.h
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptStrategy: 0
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ./: api.h fips202.c fips202.h main.c ntt.c ntt.h packing.c packing.h params.h poly.c poly.h polyvec.c polyvec.h randombytes.c randombytes.h reduce.c reduce.h rounding.c rounding.h sign.c sign.h symmetric-shake.c symmetric.h
