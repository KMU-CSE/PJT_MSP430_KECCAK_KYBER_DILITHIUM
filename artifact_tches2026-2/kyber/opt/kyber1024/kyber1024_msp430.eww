<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\kyber1024_msp430.ewp</path>
    </project>
    <batchBuild />
</workspace>
