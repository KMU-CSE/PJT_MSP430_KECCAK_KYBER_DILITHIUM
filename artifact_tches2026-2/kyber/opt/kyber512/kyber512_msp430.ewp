# IAR project kyber512_msp430.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.OGChipSelectMenu: MSP430F67791 MSP430F67791
  General.GStackSize2: 30000
  General.GHeapSize2: 1000
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 2
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f67791.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.GStackSize2: 160
  General.GHeapSize2: 160
  ICC430.CCDefines: NDEBUG
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f149.xcl
  group (top)
    ./: api.h asm_basemul_kyber.s43 asm_intt_kyber.s43 asm_ntt_kyber.s43 asm_reduce_kyber.s43 cbd.c cbd.h fips202.c fips202.h indcpa.c indcpa.h kem.c main.c matacc.c matacc.h new_asm_sha3.s43 ntt.c ntt.h params.h poly.c poly.h polyvec.c polyvec.h randombytes.c randombytes.h reduce.c reduce.h symmetric-shake.c symmetric.h verify.c verify.h
